# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx6 ST STM32F10xx6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_ARM_CM3; NDEBUG
  ICCARM.CCIncludePath2: App; Libraries\CMSIS\Core\CM3; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: App
  OBJCOPY.OOCOutputFile: bldc_backemf.hex
  ILINK.IlinkOutputFile: bldc_backemf.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  group App
    App/: Adc.c Adc.h Calc_velocity.c Calc_velocity.h comm.c Comm_Command.c Commutate_EC.c Commutate_EC.h Control_EC.c Control_ON_OFF.c Control_velocity.c Current_protection.c Current_protection.h Current_Reg.c Current_Reg.h Detect_zero_cross.c Detect_zero_cross.h Drive_param.h FreeRTOSConfig.h Gen_event_comm.c Gen_event_comm.h main.c Mes_time.c params.c Read_BackEMF.c Read_param.c Read_R1R2R3.c ReadAccTab.c rs485.c rs485.h Set_param.c sound.c sound.h stm32f10x_conf.h util.c util.h Velocity_Reg.c Velocity_Reg.h Voltage_protection.c Voltage_protection.h WriteAccTab.c
  group Libraries/CMSIS
    Libraries/CMSIS/Core/CM3/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries/CMSIS/startup
    Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group Libraries/FreeRTOS
    Libraries/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
    Libraries/FreeRTOS/Source/include/: croutine.h FreeRTOS.h list.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
    Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
    Libraries/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group Libraries/StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
